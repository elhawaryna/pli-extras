SRC_URI = "git://code.videolan.org/videolan/bitstream.git;protocol=https"
